# IAR project SimpleBLEPeripheral.ewp, settings and files
configuration CC2540 (8051, debug)
  General.OGChipSelectMenu: CC2540F256 CC2540F256
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_TIMER=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; XOSC32K_INSTALLED=TRUE; xHAL_UART_DMA=1; xHAL_UART=TRUE; xSHAMKA_UART_DEBUG; xBATT_ADC
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\Source; ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\Source\CC2540; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\CC254x\phy; ..\..\..\..\Components\ble\controller\CC254x\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\..\..\Components\ble\ROM; ..\..\Profiles\Roles\CC254x; ..\..\Profiles\Roles
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\Texas Instruments\BLE-CC254x-1.4.2.2\Projects\ble\_TRAIN\Source\linker\ti_51ew_cc2540b.xcl
configuration RELEASE (8051)
  as the first configuration, except:
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; PLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=FALSE; HAL_KEY=FALSE; XOSC32K_INSTALLED=TRUE; HAL_UART_DMA=1; HAL_UART=TRUE
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
  group APP
    ../Source/: logicBlock.h OSAL_SimpleBLEPeripheral.c simpleBLEPeripheral.c simpleBLEPeripheral.h SimpleBLEPeripheral_Main.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../../../../Components/services/saddr/: saddr.h
  group HAL/Target/CC2540/Config
    ../Source/CC2540/: hal_board_cfg.h
  group HAL/Target/CC2540/Drivers
    ../Source/CC2540/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540/Includes
    ../Source/CC2540/: hal_aes.h hal_ccm.h hal_crc.h hal_dma.h hal_mcu.h hal_types.h
  group INCLUDE
    ../../../../Components/ble/include/: att.h gap.h gatt.h gatt_uuid.h hci.h l2cap.h sm.h
    ../../../../Components/ble/host/: linkdb.h
    ../../../../Components/ble/controller/CC254x/include/: ll.h phy.h
    ../../common/npi/npi_np/: npi.h
  group LIB
    ../../Libraries/CC2540DB/bin/: CC2540_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/GATT/: gattservapp_util.c
    ../../Profiles/Roles/CC254x/: peripheral.c peripheral.h
    ../Source/: trainGATTprofile.c trainGATTprofile.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../Source/: OnBoard.c OnBoard.h
